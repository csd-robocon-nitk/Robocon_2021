Commit message: fixed the urdf

File: Final_assembly_robocon1/urdf/Final_assembly_robocon1.urdf (robot description, URDF)
Before this commit: robot Final_assembly_robocon1, 5 links, 4 joints
Links:
- link back_right: mass 0 -> 0.8
